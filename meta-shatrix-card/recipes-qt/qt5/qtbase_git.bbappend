PACKAGECONFIG_append = " accessibility eglfs fontconfig freetype gles2 linuxfb tslib"
#PACKAGECONFIG_remove = "examples tests"

